<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>919.656e6</value></param>
<param><key>label</key><value>freq</value></param>
<param><key>max</key><value>930e6</value></param>
<param><key>min</key><value>900e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>40</value></param>
<param><key>label</key><value>gain</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>mix_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>451e3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>mixfreq</value></param>
<param><key>max</key><value>10e6</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>max</key><value>20e6</value></param>
<param><key>min</key><value>32e3</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/luke/workspace/snaps/downlink_5channel_1M_bits_wFreqDev.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/luke/workspace/snaps/bi_5channel_8500ksamp.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/luke/share/snaps/downlink_5channel.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samp_rate/(64000)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>es_trigger_edge_f</key>
<param><key>id</key><value>es_trigger_edge_f_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length</key><value>1000</value></param>
<param><key>lookback</key><value>60</value></param>
<param><key>guard</key><value>300</value></param>
<param><key>type</key><value>float</value></param>
<param><key>thresh</key><value>1e-3</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>200e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>10e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
